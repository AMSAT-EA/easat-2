# Repository AMSAT-EA/easat-2

File README.md:

# easat-2
EASAT-2 satellite

This is the AMSAT EA Github repository for EASAT2 satellite project.

This is mainly an open hardware and software project and it is open to students.
The goal is designing and building a small FM repeater satellite, with CW beacon, in a pocketQube structure.

For more information visit our website at:

https://www.amsat-ea.org/easat2/

Este es el repositorio GitHub del proyecto de satélite EASAT2 de AMSAT EA.
Es un proyecto abierto de hardware y software.
El objetivo es diseñar y construir un pequeño satélite repetidor de FM, con una baliza morse, en una estructura del tipo pocketQube.

Para más información visita nuestra web en:

https://www.amsat-ea.org/easat2/

## KiCad design hardware/EPS/EPS.kicad_pcb

Parts:
C1, C2, C3, C32, C33: 22u; C_1210; Digikey 1276-3395-1-ND
C4, C5, C6, C7, C8, C9, C26, C27, C28, C29: 22n; C_0603
C10, C11, C12, C24, C25: 2.2u; C_0603; Digikey 1276-2017-1-ND
C13, C14, C15, C22, C23: 10u; C_0805; Digikey 1276-1113-1-ND
C16, C17, C18, C19, C20: 66/Ra; C_0603
C21, C30, C31: 1u; C_0603; Digikey 1276-6524-1-ND
D1, D2, D3, D9, D10, D11: 1N5819; SMini2-F4-B-B; Digikey DB2130200LCT-ND
D4, D5, D7, D8, D12: 1N4001; D_SOD-523
J1: Conn_01x11; Pin_Header_Straight_1x11_Pitch1.27mm
L1, L2, L3, L4, L5: 10u; Murata_LQH32P_footprint
P1, P2, P3, P4, P5, P6: CONN_01X02; Pin_Header_Straight_1x02_Pitch1.27mm
Q1: BC557; TO-92_Molded_Narrow
R1, R2, R3, R33, R34: M; R_0603
R4, R6, R8, R26, R28: Rd; R_0603
R5, R7, R9, R27, R29: Rc; R_0603
R10, R12, R14, R16, R18: Ra; R_0603
R11, R13, R15, R17, R19: Rb; R_0603
R20, R21, R23, R24, R30, R31: 0.2; R_1206; Digikey 311-.4LWCT-ND
R22, R25, R32: 2k; R_0603
R35: 1k; R_0603
RLIM1: 50; R_0603
U1, U2, U3, U4, U5: LTC3129; MSOP-16-Pitch0.5mm_LT3129
U6, U7, U8: ZXCT1009; SOT-23

Connections:
GND: C1.2, C2.2, C3.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.1, C21.2, C22.1, C23.1, C24.2, C25.2, C30.2, C31.2, C32.2, C33.2, J1.11, P1.2, P2.2, P3.2, P4.2, P5.2, P6.2, R5.2, R7.2, R9.2, R11.2, R13.2, R15.2, R17.2, R19.2, R22.2, R25.2, R27.2, R29.2, R32.2, U1.4 (GND), U1.6, U1.7, U1.8 (PWM), U1.13 (PGND), U1.17 (GND_EP), U2.4 (GND), U2.6, U2.7, U2.8 (PWM), U2.13 (PGND), U2.17 (GND_EP), U3.4 (GND), U3.6, U3.7, U3.8 (PWM), U3.13 (PGND), U3.17 (GND_EP), U4.4 (GND), U4.6, U4.7, U4.8 (PWM), U4.13 (PGND), U4.17 (GND_EP), U5.4 (GND), U5.6, U5.7, U5.8 (PWM), U5.13 (PGND), U5.17 (GND_EP)
I_BATT_C: C30.1, J1.4, R25.1, U7.1 (OUT)
I_BATT_D: C31.1, J1.5, R32.1, U8.1 (OUT)
I_SOLAR: C21.1, J1.3, R22.1, U6.1 (OUT)
unnamed: C4.1, L1.1, U1.14 (SW1)
unnamed: C4.2, U1.15 (BST1)
unnamed: C5.1, L2.1, U2.14 (SW1)
unnamed: C5.2, U2.15 (BST1)
unnamed: C6.1, L3.1, U3.14 (SW1)
unnamed: C6.2, U3.15 (BST1)
unnamed: C7.1, U1.11 (BST2)
unnamed: C7.2, L1.2, U1.12 (SW2)
unnamed: C8.1, U2.11 (BST2)
unnamed: C8.2, L2.2, U2.12 (SW2)
unnamed: C9.1, U3.11 (BST2)
unnamed: C9.2, L3.2, U3.12 (SW2)
unnamed: C10.1, U1.1 (Vcc)
unnamed: C11.1, U2.1 (Vcc)
unnamed: C12.1, U3.1 (Vcc)
unnamed: C13.2, C16.1, D1.2 (A), R10.1, U1.10 (Vout)
unnamed: C14.2, C17.1, D2.2 (A), R12.1, U2.10 (Vout)
unnamed: C15.2, C18.1, D3.2 (A), R14.1, U3.10 (Vout)
unnamed: C16.2, R10.2, R11.1, U1.5 (FB)
unnamed: C17.2, R12.2, R13.1, U2.5 (FB)
unnamed: C18.2, R14.2, R15.1, U3.5 (FB)
unnamed: C19.1, C22.2, D9.2 (A), R16.1, U4.10 (Vout)
unnamed: C19.2, R16.2, R17.1, U4.5 (FB)
unnamed: C20.1, C23.2, D10.2 (A), R18.1, U5.10 (Vout)
unnamed: C20.2, R18.2, R19.1, U5.5 (FB)
unnamed: C24.1, U4.1 (Vcc)
unnamed: C25.1, U5.1 (Vcc)
unnamed: C26.1, U4.11 (BST2)
unnamed: C26.2, L4.2, U4.12 (SW2)
unnamed: C27.1, U5.11 (BST2)
unnamed: C27.2, L5.2, U5.12 (SW2)
unnamed: C28.1, L4.1, U4.14 (SW1)
unnamed: C28.2, U4.15 (BST1)
unnamed: C29.1, L5.1, U5.14 (SW1)
unnamed: C29.2, U5.15 (BST1)
unnamed: D1.1 (K), D4.2 (A)
unnamed: D2.1 (K), D5.2 (A)
unnamed: D7.2 (A), D9.1 (K)
unnamed: D8.2 (A), D10.1 (K)
unnamed: D11.2 (A), R23.2, R24.2, RLIM1.2, U7.2 (S+)
unnamed: D4.1 (K), D5.1 (K), D7.1 (K), D8.1 (K), D12.1 (K), R20.2, R21.2, U6.2 (S+)
unnamed: D3.1 (K), D12.2 (A)
unnamed: P6.1, R30.1, R31.1, U8.2 (S+)
unnamed: Q1.1 (C), RLIM1.1
unnamed: R4.2, R5.1, U1.3 (MPPC)
unnamed: R6.2, R7.1, U2.3 (MPPC)
unnamed: R8.2, R9.1, U3.3 (MPPC)
unnamed: R23.1, R24.1, R30.2, R31.2, U7.3 (S-), U8.3 (S-)
unnamed: R26.2, R27.1, U4.3 (MPPC)
unnamed: R28.2, R29.1, U5.3 (MPPC)
PTT: J1.2, Q1.2 (B), R35.2
PV+X_IN: C1.1, P1.1, R1.2, R4.1, U1.2 (RUN), U1.16 (Vin)
PV+X_OUT: J1.6, R1.1
PV+Y_IN: C2.1, P2.1, R2.2, R6.1, U2.2 (RUN), U2.16 (Vin)
PV+Y_OUT: J1.7, R2.1
PV+Z_IN: C3.1, P3.1, R3.2, R8.1, U3.2 (RUN), U3.16 (Vin)
PV+Z_OUT: J1.8, R3.1
PV-X_IN: C32.1, P4.1, R26.1, R33.2, U4.2 (RUN), U4.16 (Vin)
PV-X_OUT: J1.9, R33.1
PV-Y_IN: C33.1, P5.1, R28.1, R34.2, U5.2 (RUN), U5.16 (Vin)
PV-Y_OUT: J1.10, R34.1
VBUS: D11.1 (K), J1.1, Q1.3 (E), R20.1, R21.1, R35.1, U6.3 (S-)

Notes on the sheet:
Cin 22u at least for MPPC
Vin = 1.175V*(1+Rd/Rc)
FB and MPPC resistors in MOhm range
C 4.7n to 47n
L see datasheet
Vout = 1.175V*(1+Ra/Rb)
battery connector
only works when current flowing out of battery
2V = 250mA
VBUS

Board: 2 copper layers, 60.0 x 55.0 mm, 101 parts (0 on the bottom side), 66 nets.

## KiCad design hardware/MCU/MCU.kicad_pcb

Parts:
C1, C7, C9, C11: 100nF; C_0603_HandSoldering
C2, C4: 18pF; C_0603_HandSoldering
C3, C5: 1uF; C_0603_HandSoldering
C6, C8, C10, C12, C13: 10nF; C_0603_HandSoldering
D1, D2: LED; LED_1206
D3, D5: ZENER; D_SOD-123
D4: ZENER; D_SOD-323_HandSoldering
FID1, FID2, FID3: FIDUCIAL; Fiducial_1mm_Dia_2.54mm_Outer_CopperTop
P1, P2, P3, P4: CONN_01X05; Molex_MicroLatch-53253-0570_05x2.00mm_Straight
R1, R2: 470; R_0603_HandSoldering
R3, R5: 4K7; R_0603_HandSoldering
R4: 6,19K; R_0603_HandSoldering
R6, R13: 10K; R_0603_HandSoldering
R7: 4,99K; R_0603_HandSoldering
R8: 6,65K; R_0603_HandSoldering
R9, R11, R12: 1K; R_0603_HandSoldering
R10: R; R_0603_HandSoldering
SP1: SPEAKER; MagneticBuzzer_Kingstate_KCG0601
U1: MAX6369; SOT-23-8
U2: TC1262-30VDB; SOT-223
U3: DS18B20; MSOP-8_3x3mm_Pitch0.65mm
U4: PIC18F45K22; LQFP-44_10x10mm_Pitch0.8mm
U5: LT6005; SSOP-16_3.9x4.9mm_Pitch0.635mm

Connections:
/AGC: P3.4, U4.21 (RA2)
/BEACON_MODE: P4.5, U4.14 (RB4)
/BEACON_ON: R4.2, U4.41 (RD3)
/BUZZER: D4.1 (K), SP1.1, U4.40 (RD2); also elsewhere on the board
/DIS: C7.1, P1.5
/ENA: P3.1, U4.26 (RE1)
/F_BEA: P3.2, U5.7
/F_RF_IN: R10.1, U4.24 (RA5), U5.10
/HIPWR: P4.4, U4.11 (RB3)
/LED_G: R1.1, U4.2 (RD4)
/LED_R: R2.1, U4.39 (RD1)
/PGC: P2.5, U4.16 (PGC/RB6)
/PGD: P2.4, U4.17 (PGD/RB7)
/PTT: P4.1, U4.9 (RB1)
/PWD: D5.1 (K), P1.4, U4.8 (RB0)
/RA6: C2.1, U4.31 (RA6); also elsewhere on the board
/RA7: C4.1, U4.30 (RA7); also elsewhere on the board
/RF_IN: P3.5, U5.12 (+)
/RPT: P4.2, U4.10 (RB2)
/SOL: D3.1 (K), P1.3, U4.20 (RA1)
/TEMP: R3.1, U3.4 (DQ), U4.22 (RA3)
/VBAT: R5.2, R6.1, U4.19 (RA0)
/WDI: U1.1 (WDI), U4.3 (RD5)
/~WDO/MCLR: P2.1, R13.2, U1.7 (~WDO), U4.18 (~MCLR~/VPP/RE3)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.1, D1.1 (K), D2.1 (K), D3.2 (A), D4.2 (A), D5.2 (A), P1.2, P2.3, P3.3, P4.3, R6.2, R9.2, R12.1, SP1.2, U1.2 (GND), U2.2 (GND), U2.4 (GND), U3.5 (GND), U4.6 (VSS), U4.29 (VSS), U5.13 (V-); also elsewhere on the board
unnamed: C6.1, R4.1, U5.3 (+)
unnamed: C7.2, U4.27 (RE2)
unnamed: C12.2, R8.2, U5.5 (+)
unnamed: C13.1, U5.6 (-)
unnamed: C13.2, R7.2, R8.1
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: R7.1, U5.1, U5.2 (-)
unnamed: R9.1, R10.2, U5.11 (-)
unnamed: R11.1, R12.2, U5.14 (+)
unnamed: U5.15 (-), U5.16
VCC: C1.1, C5.1, C8.1, C9.1, C10.1, C11.1, P2.2, R3.2, R11.2, R13.1, U1.4 (SET0), U1.5 (SET1), U1.6 (SET2), U1.8 (VCC), U2.3 (VOUT), U4.7 (VDD), U4.28 (VDD), U5.4 (V+); also elsewhere on the board
VDD: C3.1, P1.1, R5.1, U2.1 (VIN)

Notes on the sheet:
MPTT
2.7 V
DEV
3.2 V
Mechanics
Interfaces
Protections
Power
LEDs
MCU
Watchdog
Temperature
Buzzer
Unused

Board: 2 copper layers, 47 parts (0 on the bottom side), 38 nets, no tracks yet.

Other parts of the board:
C14: 10nF; C_0603_HandSoldering
C15: 100nF; C_0603_HandSoldering
P5: CONN_01X02; Molex_KK-6410-02_02x2.54mm_Straight
X1: CRYSTAL_SMD; Crystal_SMD_0603-4pin_6.0x3.5mm

Their connections:
/BUZZER: P5.1; also elsewhere on the board
/RA6: X1.1; also elsewhere on the board
/RA7: X1.2; also elsewhere on the board
GND: C14.2, C15.2, P5.2, X1.3; also elsewhere on the board
VCC: C14.1, C15.1; also elsewhere on the board

## KiCad design hardware/easat2.kicad_pcb

Board: 2 copper layers, 93 parts (0 on the bottom side), 59 nets.

Parts:
C1, C2, C3, C19, C20: 22u; C_1210
C4, C5, C6, C7, C8, C9, C21, C22, C23, C24: 22n; C_0603
C10, C11, C12, C25, C26: 2.2u; C_0603
C13, C14, C15, C28, C29: 10u; C_0805
C16, C17, C18, C30, C31: 66/Ra; C_0603
C27, C32: 1u; C_0603
D1, D2, D3, D7, D8: DB2S31600L; SOD-523
D4, D5, D6, D9, D10: DB2130200L; SMini2-F4-B-B
L1, L2, L3, L4, L5: 10u; C_1210
P1, P3, P4, P5, P6, P7: CONN_01X02; Pin_Header_Straight_1x02
P2: CONN_01X05; Pin_Header_Straight_1x05
Q1: FDV301N; SOT-23
R1, R3, R5, R16, R18: Rd; R_0603
R2, R4, R6, R17, R19: Rc; R_0603
R7, R8, R9, R20, R21, R22: 100k; R_0603
R10, R12, R14, R26, R28: Ra; R_0603
R11, R13, R15, R27, R29: Rb; R_0603
R23: 100; R_0603
R24, R30: 0.4; R_1206
R25, R31: 2k; R_0603
U1, U2, U3, U4, U5: LTC3129; MSOP-16-1EP-VIA_3x4mm_Pitch0.5mm
U6, U7: ZXCT1009; SOT-23

Connections:
+BATT: P2.1, R24.1, R30.2, U6.3, U7.3
/MPPT/VR_Shdn: D1.1, D2.1, D3.1, D7.1, D8.1, Q1.3
/MPPT/solar: D4.1, D5.1, D6.1, D9.1, D10.1, R24.2, U6.2
DISABLE_SOLAR: P2.4, R23.1
GND: C1.2, C2.2, C3.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.1, C19.2, C20.2, C25.2, C26.2, C27.2, C28.1, C29.1, C32.2, P1.2, P2.5, P3.2, P4.2, P5.2, P6.2, P7.2, Q1.1, R2.2, R4.2, R6.2, R11.2, R13.2, R15.2, R17.2, R19.2, R22.2, R25.2, R27.2, R29.2, R31.2, U1.4, U1.8, U1.13, U1.17, U2.4, U2.8, U2.13, U2.17, U3.4, U3.8, U3.13, U3.17, U4.4, U4.8, U4.13, U4.17, U5.4, U5.8, U5.13, U5.17
I_BATT: C32.1, P2.3, R31.1, U7.1
I_SOLAR: C27.1, P2.2, R25.1, U6.1
unnamed: C4.1, L1.1, U1.14
unnamed: C4.2, U1.15
unnamed: C5.1, L2.1, U2.14
unnamed: C5.2, U2.15
unnamed: C6.1, L3.1, U3.14
unnamed: C6.2, U3.15
unnamed: C7.1, U1.11
unnamed: C7.2, L1.2, U1.12
unnamed: C8.1, U2.11
unnamed: C8.2, L2.2, U2.12
unnamed: C9.1, U3.11
unnamed: C9.2, L3.2, U3.12
unnamed: C10.1, U1.1
unnamed: C11.1, U2.1
unnamed: C12.1, U3.1
unnamed: C13.2, C16.1, D4.2, R10.1, U1.10
unnamed: C14.2, C17.1, D5.2, R12.1, U2.10
unnamed: C15.2, C18.1, D6.2, R14.1, U3.10
unnamed: C16.2, R10.2, R11.1, U1.5
unnamed: C17.2, R12.2, R13.1, U2.5
unnamed: C18.2, R14.2, R15.1, U3.5
unnamed: C21.1, L4.1, U4.14
unnamed: C21.2, U4.15
unnamed: C22.1, L5.1, U5.14
unnamed: C22.2, U5.15
unnamed: C23.1, U4.11
unnamed: C23.2, L4.2, U4.12
unnamed: C24.1, U5.11
unnamed: C24.2, L5.2, U5.12
unnamed: C25.1, U4.1
unnamed: C26.1, U5.1
unnamed: C28.2, C30.1, D9.2, R26.1, U4.10
unnamed: C29.2, C31.1, D10.2, R28.1, U5.10
unnamed: C30.2, R26.2, R27.1, U4.5
unnamed: C31.2, R28.2, R29.1, U5.5
unnamed: D1.2, R7.1, U1.2
unnamed: D2.2, R8.1, U2.2
unnamed: D3.2, R9.1, U3.2
unnamed: D7.2, R20.1, U4.2
unnamed: D8.2, R21.1, U5.2
unnamed: P1.1, R30.1, U7.2
unnamed: Q1.2, R22.1, R23.2
unnamed: R1.2, R2.1, U1.3
unnamed: R3.2, R4.1, U2.3
unnamed: R5.2, R6.1, U3.3
unnamed: R16.2, R17.1, U4.3
unnamed: R18.2, R19.1, U5.3
PV1_IN: C1.1, P3.1, R1.1, R7.2, U1.16
PV2_IN: C2.1, P4.1, R3.1, R8.2, U2.16
PV3_IN: C3.1, P5.1, R5.1, R9.2, U3.16
PV4_IN: C19.1, P6.1, R16.1, R20.2, U4.16
PV5_IN: C20.1, P7.1, R18.1, R21.2, U5.16

## Code that names these connections

File software/official/main_project/easat2_pinouts.h:

/*
 *                                                       
 * Project     : EASAT2                                            
 * File        : easat2_pinouts.h
 *
 * Description : This file include all the necessary project includes
 * Last update : 01 April 2017                                              
 *                                                                            
*/

#ifndef EASAT2_PINOUTS_H
#define	EASAT2_PINOUTS_H

#include <xc.h>
#include "easat2_config.h"

// pinout configuration, look in initialize file for i/o analog/digital conf

// ADC channels

#define PINOUT_ADC_BATTERY_VOLTAGE_CHANNEL    0   // AN0  (RA0)
#define PINOUT_ADC_SOLAR_CURRENT_CHANNEL      1   // AN1  (RA1)
                                                  // AN2  (RA2) used by DAC
                                                  // AN3  is used as digital
#define PINOUT_ADC_RF_IN_SIGNAL_POWER_CHANNEL 4   // AN4  (AN4 is pin RA5)
#define PINOUT_ADC_BATTERY_CURRENT_CHANNEL    12  // AN12 (RB0)

// PORTA, configured as input (except RA3 termomether, that is bidirectional,
//        and RA2, where DAC is found)

#define PINOUT_BATTERY_VOLTAGE_CHANNEL    (PORTAbits.RA0) // used as ADC channel
#define PINOUT_SOLAR_CURRENT_CHANNEL      (PORTAbits.RA1) // used as ADC channel
#define PINOUT_AGC_DAC                    (PORTAbits.RA2) // DAC for AGC
#define PINOUT_THERMOMETER                (PORTAbits.RA3) // digital termomether
                                                          // RA4 avaliable
#define PINOUT_RF_IN_SIGNAL_POWER_CHANNEL (PORTAbits.RA5) // used as ADC channel
                                                          // RA6 crystal
                                                          // RA7 crystal
// PORTB, configured as output except RB0

#define PINOUT_BATTERY_CURRENT_CHANNEL    (PORTBbits.RB0) // used as ADC channel
#define PINOUT_REPEATER_PTT_ON            (PORTBbits.RB1) // repeater on (PTT-ENA line)
#define PINOUT_REPEATER_MODE_ON           (PORTBbits.RB2) // high for repeater mode on
#define PINOUT_HIPOWER_MODE_ON            (PORTBbits.RB3) // high for high power mode on
#define PINOUT_BEACON_MODE_ON             (PORTBbits.RB4) // high for beacon mode on
                                                          // RB5 avaliable
                                                          // RB6 external prog line
                                                          // RB7 external prog line
// PORTC

// PORTD, configured as output
                                                           // RD0 avaliable
#define PINOUT_BEACON_LED                 (PORTDbits.RD1)  // main test red led pin
#define PINOUT_BUZZER                     (PORTDbits.RD2)  // test buzzer 1 Khz square wave
#define PINOUT_BEACON_OUT                 (PORTDbits.RD3)  // Audio beacon out, same as buzzer
#define PINOUT_TIMER_LED                  (PORTDbits.RD4)  // aux green blinking timer led
#define PINOUT_WATCHDOG                   (PORTDbits.RD5)  // out signal to watchdog
                                                           // RD6 avaliable
                                                           // RD7 avaliable
// PORTE

// TRIS registers that change while execution

#define PINOUT_BUZZER_PWM                 (TRISDbits.TRISD2) // PWM CCP P2B
#define PINOUT_BEACON_AUDIO_PWM           (TRISDbits.TRISD3) // PWM CCP P2C

#endif

## Commit log (part)

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2016-08-26 Added KiCAD project
2016-08-26 First draft of the MPPT and power circuit
2016-08-27 Added ZXCT1009 current monitors
2016-09-06 Corrected current shunt name: ZXCT1009
2016-09-07 Documentos iniciales del proyecto
    Documentos sobre estudios de energía, potencia, y propuesta inicial del
    satélite.
2016-09-07 Added datasheets and other useful docs
2016-09-07 Adding ZXCT1009 datasheet
2016-09-08 Añadida plantilla para documentos
2016-09-09 Added voltage regulator TC1262
2016-09-17 Updated MPPT
    5 converter blocks, footprints and Digikey references for many components.
2016-09-18 First version of MPPT PCB
2016-09-19 Added "AMSAT-EA" to the MPPT PCB silkscreen
2016-09-21 Adding info for DRA818V and DRA818U RF modules
2016-09-21 Added DRA818U PinOut and configuration with Arduino
2016-10-01 Especificación de requisitos del subsistema MPPT
    Especificación de requisitos del subsistema MPPT
2016-10-03 Ficheros de includes del configuración del PIC y librería retardos
    Se incluyen los ficheros que configuran los flags del PIC, el mapeo de
    la memoria EEPROM con la tabla MORSE y un mensaje para pruebas, así como
    la librería de retardos.
2016-10-07 Comments translated to english
    Comments translated to english
2016-10-07 Code comments translated to english
    Code comments translated to english
2016-10-09 Minor update of the MCU and MPPT specification docs
    Minor update of the MCU and MPPT specification docs
2016-10-12 Code initial structure with empty functions
    Code initial structure with empty functions
2016-10-22 Initial architecture document
    Initial architecture document that describes the different system
    modules and how the interact between them.
2016-10-27 First C version to test beacon hardware in development
    This is the first version to test the beacon hardware (see the LED
    light, and the buzzer sound at 1 Khz).
2016-10-31 Working beacon stable code
    First working stable beacon code. 32 WPM, 3 mins wait
2016-11-08 MCU project created
2016-11-12 PIC18F45K22 symbol created. MCU schematic: MCU, resonator
2016-11-12 MCU: Connectors, watchdog, buzzer added
2016-11-15 LTSpice simulation for 1KHZ Low Pass Filter. Need to adjust with commercial values for passive components
2016-11-20 More accurate gains for handeld yagi on simulation
    3element VHF -> 7dBi
    7element UHF -> 12dBi
2017-01-02 MCU schematic: Low Pass Filter for BEA signal. DRC cheched and Netlist generated
2017-01-12 Some footprints added to MCU components
2017-01-14 All footprints added. Need to check them before manufacturing. Placement started
2017-01-15 MCU board outline defined. Mechanical holes added. Routing started
2017-01-28 High priority interruptions working. Added AGC, energy and command skeleton functions
    Highr priority interruption used for battery consumption, AGC control
    and command configured. Added blinking LED for debugging in RD4. AGC and
    command skeleton functions added
2017-02-15 Added ASK/FSK SI4464 datasheet
    Added ASK/FSK SI4464 datasheet
2017-02-20 PIC schematic of 64 pins. Reorganized pinout
2017-03-02 Radiometrix 100mW 433 Mhz TX module
    Radiometrix 100mW 433 Mhz TX module
2017-03-02 Radiometrix VHF FM custom frequency receiver
    Frequency customizable in order
2017-03-06 Doc about how to charge Lithium-Ion batteries
2017-03-08 Añadido documento de requisitos HW de la MCU en formato PDF
2017-03-08 Corregidas erratas en el documento de requisitos de la MCU. Añadido regulador al esquematico y ajustadas las conexiones acorde a los requisitos
2017-03-10 Eduardo files about antenna, structure and transponder
    Eduardo files about antenna, structure and transponder
2017-03-14 Añadida libreria del amplificador operacional LT6005. Añadido a los esquematicos.
2017-03-15 Audio squelch circuit to ADC for initial testing
    Audio squelch circuit to ADC for initial testing (Eduardo)
2017-03-15 Deleting old MCU specification file
    Deleting old MCU specification file
2017-03-17 Added LT6005 datasheet
    Added LT6005 datasheet
2017-03-20 XC8 Microchip compiler guide
    XC8 Microchip compiler guide
2017-03-22 Texas Instruments AN-1451 LM4935 AUDIO AGC
    Texas Instruments AN-1451 LM4935 AUDIO AGC (as an example of how does it work internally)
2017-03-23 Puestas todas las huellas. Primera colocacion de los componentes hecha. A la espera de la revision de los esquematicos para rutar
2017-04-01 Pinout configuration centraliced in one file
    Pinout configuration centraliced in one file
2017-04-01 Updated pinout configuration file and splitted MCU initialize function
    Updated pinout configuration file and splitted MCU initialize function
2017-04-03 Añadidas señales PTT, RPT, HIPWR, BEACON_MODE. Añadido un conector
2017-04-04 Transponder block diagram with control lines
    Transponder block diagram with control lines (Eduardo EA3GHS)
2017-04-08 Weak pull-up port resistors explicit disable, PWM initial files, errata fixed in pinouts
    Weak pull-up port resistors explicit disable, PWM initial files, errata
    fixed in pinouts
2017-04-12 PWM beacon working. Added signal to hardware watchdog
    PWM beacon working. Added signal to hardware watchdog. Also some code
    reorganization.
2017-04-17 Radiometrix SAT sub-band customizable modules
    These would be the Radiometrix customizable modules for the satellite sub-bands.
2017-04-29 Modificaciones para fabricación: - Añadidos campos en los componentes (esquemáticos). - Añadida carpeta Documentos/Montador/ - Creada primera versión del BOM (formato HTML, CSV y XML).
2017-05-07 Squelch level detector - fast version
    Squelch level detector - fast version. Also minor typos in files
2017-05-15 Placa MCU rutada. Falta: - Mejorar la colocación de algunas pistas - Comprobar las reglas para fabricación - Generar los ficheros de fabricación
2017-05-15 MCU: Añadidos ficheros de fabricacion. Lista para fabricar la versión 1.0 a falta de retoques de serigrafía (logo)
2017-05-28 ASK tester - parameters - added debugging LED
    ASK tester - parameters - added debugging LED
2017-06-01 ASK decoder first version - untested
    ASK decoder main code, first version - untested
2017-06-03 MCU Version 1.0 lista para fabricación. Ficheros generados.
2017-06-05 - Esquematicos generados - Archivos de fabricacion - BOM para Farnell
2017-06-12 ASK related datasheets and docs
    ASK related datasheets and docs
2017-06-14 Deleting unused files
    Deleting unused files
2017-06-14 ASK command decode initial implementation
    ASK command decode initial implementation
2017-07-31 Create Ensayos Termicos
2017-07-31 Created folder for thermal design and tests
    Created folder for thermal design and tests
2017-09-05 Corregidos errores en el esquematico de la MCU: - Se incorpora el pin MCLR al conector de programacion (P2) y se ordenan acorde al pinout del programador PicKit 3 - La alimentación del microcontrolad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
2017-09-20 DRA818V specs
    DRA818V specs
2017-09-20 RDA1846S IC programmable transceiver RS-UV3
    RDA1846S IC programmable transceiver RS-UV3
2017-09-22 FEASABILITY STUDY OF A POCKETQUBE PLATFORM
    FEASABILITY STUDY OF A POCKETQUBE PLATFORM
2017-10-01 ASK tester working (50 bits / second) 32 bits
    ASK tester working (50 bits / second) 32 bits
2017-10-10 Memoria técnica del transpondedor (EA3GHS)
    Memoria técnica del transpondedor diseñado por Eduardo Alonso (EA3GHS)
2017-10-12 The PocketQube Concept
    The PocketQube Concept - California State Polytechnic University
2017-10-16 Memoria ténica transponder picosatélite
    Memoria ténica transponder picosatélite (movida)
2017-10-16 Memoria técnica transponder picosatélite
    Memoria técnica transponder picosatélite
2017-10-18 Presentación EASAT2 y Picosatélites Universidad Europea
    Presentación EASAT2 y Picosatélites Universidad Europea
2017-10-19 Presentación EASAT2 Universidad Europea
    Presentación EASAT2 - Picosatélites Universidad Europea Oct 2017 por Eduardo Alonso EA3GHS, Felix Paez EA4GQS.
2017-10-19 Presentación EASAT2 IberRadio 2017 Ávila
    Presentación EASAT2 IberRadio 2017 Ávila por Félix Páez EA4GQS - Eduardo Alonso EA3GHS en nombre del equipo de EASAT2
2017-10-20 IC AD9364 transceiver datasheet
    IC AD9364 transceiver datasheet
2017-10-28 Update README.md
    Actualizada descripción del proyecto en GitHub
2017-11-04 Added 3D models of header connectors
2017-12-29 Schottky Barrier Diode DB2130200L datasheet
    Schottky Barrier Diode DB2130200L datasheet upload used in MPPT
2017-12-29 Microchip Battery charger MCP73841
    Microchip Battery charger MCP73841 IC
2018-01-02 Batteries related documents
    Batteries related documents (safety, procedures...)
2018-01-03 Varta Battery and Dual comparator Sheets
    Varta Battery and Dual comparator Sheets (used in Swiss Cube)
2018-01-06 Evolution of MPPT design
    Evolution of MPPT design. Added additional safe diodes, some parts
    reorganized. Numeration of resistors, capacitors and diodes made more
    clear.
2018-01-06 MPPT Evolution - generated new PDF schematic file
    MPPT Evolution - generated new PDF schematic file
2018-01-07 Added out pins from panels to MCU
    Added out pins from panels to MCU so voltage of each one can be measured
    by CPU
2018-01-07 Generated new MPPT PDF schematic
    Generated new MPPT PDF schematic
2018-01-09 Varta PoliFlex batteries family
    Varta PoliFlex batteries family
2018-01-12 Varta Poliflex PLF 523450C datasheet
    Varta Poliflex PLF 523450C datasheet
2018-02-12 Varta PoliFlex Handbook
    Varta PoliFlex Handbook. PLF523450 data included
2018-02-13 Microchip MIC2045 MOSFET switches
    Microchip MIC2045 MOSFET switches for battery connect / disconnect protection
2018-02-14 Zero 2 Infinity Bloostar Payload User Guide
    Zero 2 Infinity Bloostar Payload User Guide
2018-02-21 Latch up protection techniques and parts
    Latch-Up Protection For MOSFET Drivers
    BU-CA Series - TBU ® High-Speed Protectors
2018-03-03 Placement terminado para la versión 2.0 de la MCU
2018-03-11 Primer borrador de la PCB. Basada en el esquemático del documento. Los valores de elementos pasivos no son los finales, solo se han montado para comprobar que se puede diseñar para que ocupe 1U de po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
2018-03-12 Add files via upload
    ojales en MLI o remaches metálicos.. (idea para mecanizado)
2018-04-02 MPPT evolution added missing models, replaced componentes
    MPPT evolution added missing models, replaced componentes, routed again.
2018-04-04 PQ60 standard rev 1.1
    PQ60 standard rev 1.1
2018-04-06 Added Radiation Sensor BG51 datasheet
    Added Radiation Sensor BG51 datasheet
2018-04-07 MPPT board big version for electrical testing
    MPPT board big version for electrical testing
2018-04-11 Added ground planes to MPPT evolution
    Added ground planes to MPPT evolution. Deleted big PCB version
2018-04-16 MIKROE-2806 LTC3129 prototype board datasheet
    MIKROE-2806 LTC3129 prototype board datasheet
2018-04-29 LTC3129-1 fixed voltage LTC3129 version datasheet
    LTC3129-1 fixed voltage LTC3129 version datasheet
2018-05-03 LP2951N / RT9728A
    LP2951N voltage regulator and RT9728A Power Switch with Programmable Current Limit Datasheets
2018-05-04 Alba Orbital Deployer ICD 0.1
    Alba Orbital Deployer ICD 0.1
2018-05-18 IHU datasheet
    IHU datasheet
2018-05-21 SPV1040 - High efficiency solar battery charger
    SPV1040 - High efficiency solar battery charger
2018-05-21 EPS clean version
    EPS clean version
2018-05-23 Create Ensayos_Impactos
2018-05-28 PCB EPS
    versión 0
2018-05-30 Actualización PCB EPS
2018-06-21 Uploaded 1N4001 and 1N5819 diodes datasheets
    Uploaded 1N4001 and 1N5819 diodes datasheets
2018-06-28 PocketQube Standard Issue 1
    PocketQube Standard Issue 1
2018-07-24 LM335 Analog Thermometer
    LM335 Analog Thermometer
